Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_38_X1YjC/format_1/3258(architecture=300).ifc
Time: 2025-09-01T09:05:35
Made in: PARTsolutions

# IfcProject, 3258(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3258(architecture=300)
In: BUILDING
Description: 3258(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3258
ePset_PARTsolutions - NB: 3258(architecture=300); NN: 3258; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3258(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3258; B: 3258_aluvia_800x800.png; C: ALUVIA; E: KALDEWEI; EF000049: 800; EF004567: 800; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 800; etim7_EC003246_LENGTH: 800
